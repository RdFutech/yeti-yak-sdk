EXTRA_OEMAKE += "NSS_DISABLE_DBM=1 NSS_USE_SYSTEM_SQLITE=1"
